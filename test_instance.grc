options:
  parameters:
    generate_options: qt_gui
    id: prod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '3'
    type: float
  states: {}
- name: howto_square3_ff_0
  id: howto_square3_ff
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', howto_square3_ff_0, '0']
- [howto_square3_ff_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
